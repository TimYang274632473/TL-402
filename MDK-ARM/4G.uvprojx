# Keil uVision project 4G.uvprojx, settings and files
target 4G (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L071CBTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: 4G +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L071xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;..\HARDWARE\inc;..\sys\delay;..\Middlewares\Third_Party\FreeRTOS\Source\include;..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS;..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM0
  library: MicroLIB
  memory RVCT4: ROM 0x8005000 size 0x1b000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32l071xx.s
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Tasks
    ../HARDWARE/src/: app_task_1.c app_task_2.c app_task_3.c app_task_4.c app_task_5.c app_task_timer.c
  group app
    ../HARDWARE/src/: main.c stm32l0xx_it.c CMDHandle.c freertos.c wm8960.c w25qxx.c bma250.C maincontrol.c keyscan.c usart1.c gsm.c wifi.c gps.c geo.c ota.c iic.c rtc.c spi.c gpio.c usart.c iwdg.c
  group Drivers/STM32L0xx_HAL_Driver
    ../HARDWARE/src/: stm32l0xx_hal_msp.c
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_lptim.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_adc.c stm32l0xx_hal_flash.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_i2c.c stm32l0xx_hal_uart.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_cortex.c stm32l0xx_hal_iwdg.c stm32l0xx_hal.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group sys
    ../: note.txt
    ./: Record.txt
software components: CMSIS:CORE 5.0.1
